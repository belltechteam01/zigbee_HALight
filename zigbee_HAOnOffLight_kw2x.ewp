# IAR project zigbee_HAOnOffLight_kw2x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW22D512xxx5 Freescale MKW22D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKW22D512VHA5; FSL_RTOS_FREE_RTOS; FRDM_KW24D512; gSecLib_HWSupport_d=gSecLib_MMCAUSupport_d; PROCESSOR_KINETIS; gMacFeatureSet_d=gMacFeatureSet_ZPM4_d; gPhyRxPBTransferThereshold_d=1; gBeeStackZcRsRNPSp2_d=1; gBeeStackIncluded_d=1; gStandardSecurity_d=1; gMeshNetworkingCapability_d=1; gZigbeeProIncluded_d=1
  ICCARM.CCDiagSuppress: Pe014,Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: app/zbpro/source/zbpro_app/HaOnOffLight/BeeAppConfig.h
  ICCARM.CCIncludePath2: $_KSDK_PATH_KINETIS_BEESTACK_500_$/rtos/FreeRTOS/port/iar; $_KSDK_PATH_KINETIS_BEESTACK_500_$/rtos/FreeRTOS/include; $_KSDK_PATH_KINETIS_BEESTACK_500_$/rtos/FreeRTOS/src; $_KSDK_PATH_KINETIS_BEESTACK_500_$/rtos/FreeRTOS/config/KW24D5/iar; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/usb_core/device/include/frdmkw24; boards/frdmkw24; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/devices/MKW22D5/startup; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/drivers/inc; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/hal/inc; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/system/inc; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/osa/inc; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/CMSIS/Include; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/CMSIS/Include/Device; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/utilities/inc; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/devices; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/usb_core/include; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/usb_core/device/include; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/adapter/sources; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/adapter/sources/sdk; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/usb_core/device/sources/classes/include; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/usb_core/device/sources/classes/include/config; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/usb_core/device/sources/classes/cdc; app/zbpro/source/endpoints/HAOnOffLight; app/zbpro/source/zbpro_app/HaOnOffLight; framework/Common; framework/FSCI/Interface; framework/FSCI/Source; framework/MemManager/Interface; framework/Messaging/Interface; framework/NVM/Interface; framework/NVM/Source; framework/OSAbstraction/Interface; framework/OtaSupport/Interface; framework/Panic/Interface; framework/RNG/Interface; framework/SerialManager/Interface; framework/Shell/Interface; framework/TimersManager/Interface; framework/TimersManager/Source; framework/Utils/FunctionLib; framework/Utils/Lists; framework/Utils/ModuleInfo; framework/Utils/SecLib; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/drivers/src/mmcau/asm-cm4; drv/Portable/Eeprom/Interface; drv/Portable/LED/Interface; drv/Portable/GPIO_IrqAdapter; drv/Portable/Keyboard/Interface; drv/Portable/Flash_Adapter; drv/Portable/TMR_Adapter; drv/Portable/SPI_Adapter; drv/Portable/USB_VirtualCom; $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/drivers/src/flash/C90TFS/drvsrc/include; zbpro/base/interface; zbpro/base/ztc/Interface; zbpro/base/ztc/Source; zbpro/core/interface; zbpro/core/zdo/interface; zbpro/zcl; zbpro/zcl/ha; zbpro/zcl/hc; zbpro/zcl/se; app/zbpro/source/asl; app/zbpro/source/configure; app/zbpro/source/init; app/zbpro/source/endpoints; app/zbpro/source/zbpro_appinit; framework/LPM/Interface/KW2xD; ieee_802_15_4/Source/Phy/Source/MCR20A/MCR20Drv; ieee_802_15_4/Source/Phy/Source/XcvrSpi; ieee_802_15_4/Source/Phy/Interface; ieee_802_15_4/Source/Mac/Interface; ieee_802_15_4/Source/App
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: $_KSDK_PATH_KINETIS_BEESTACK_500_$/rtos/FreeRTOS/config/KW24D5/iar
  OBJCOPY.OOCOutputFile: zigbee_HAOnOffLight_frdmkw24_freertos_Zc_Rs.srec
  ILINK.IlinkOutputFile: zigbee_HAOnOffLight_frdmkw24_freertos.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __heap_size__=0x6200; __ram_vector_table__=1
  ILINK.IlinkIcfFile: platform/devices/MKW24D5/linker/iar/MKW24D512xxx5_connectivity.icf
  ILINK.IlinkAdditionalLibs: $_KSDK_PATH_KINETIS_BEESTACK_500_$/lib/ksdk_freertos_lib/iar/KW24D5/debug/libksdk_platform_freertos.a; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/usb_core/device/build/iar/usbd_sdk_frdmkw24_freertos/debug/libusbd_freertos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW22D512VHA5; FSL_RTOS_FREE_RTOS; FRDM_KW24D512; gSecLib_HWSupport_d=gSecLib_MMCAUSupport_d; PROCESSOR_KINETIS; gMacFeatureSet_d=gMacFeatureSet_ZPM4_d; gPhyRxPBTransferThereshold_d=1; gBeeStackZcRsRNPSp2_d=1; gBeeStackIncluded_d=1; gStandardSecurity_d=1; gMeshNetworkingCapability_d=1; gZigbeeProIncluded_d=1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkAdditionalLibs: $_KSDK_PATH_KINETIS_BEESTACK_500_$/lib/ksdk_freertos_lib/iar/KW24D5/release/libksdk_platform_freertos.a; $_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/usb_core/device/build/iar/usbd_sdk_frdmkw24_freertos/debug/libusbd_freertos.a
  group app/zbpro/source/asl
    app/zbpro/source/asl/: ASL_UserInterface.c ASL_UserInterface.h ASL_ZCLInterface.c ASL_ZCLInterface.h ASL_ZdpInterface.c ASL_ZdpInterface.h
  group app/zbpro/source/configure
    app/zbpro/source/configure/: ApplicationConf.h AppToMacPhyConfig.h AppToPlatformConfig.h GlobalVars.c
  group app/zbpro/source/endpoints
    app/zbpro/source/endpoints/: EndPoint.c EndPoint.h
  group app/zbpro/source/endpoints/HAOnOffLight
    app/zbpro/source/endpoints/HAOnOffLight/: EndPointConfig.c EndPointConfig.h HaOnOffLightEndPoint.c
  group app/zbpro/source/init
    app/zbpro/source/init/: AppInit.c AppInit.h
  group app/zbpro/source/zbpro_app/HAOnOffLight
    app/zbpro/source/zbpro_app/HaOnOffLight/: BeeApp.c BeeApp.h BeeAppConfig.h
  group app/zbpro/source/zbpro_appinit
    app/zbpro/source/zbpro_appinit/: BeeAppInit.c BeeAppInit.h
  group board
    boards/frdmkw24/: board.c board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group drv/Eeprom/Source
    drv/Portable/Eeprom/Source/: Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group drv/Flash/Source
    $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c FlashCommandSequence.c FlashEraseSector.c FlashInit.c FlashProgram.c FlashVerifySection.c
  group drv/Flash_Adapter
    drv/Portable/Flash_Adapter/: Flash_Adapter.c Flash_Adapter.h
  group drv/GPIO_IrqAdapter
    drv/Portable/GPIO_IrqAdapter/: GPIO_IrqAdapter.c GPIO_IrqAdapter.h
  group drv/Keyboard/Source
    drv/Portable/Keyboard/Source/: Keyboard.c
  group drv/LED/Source
    drv/Portable/LED/Source/: LED.c
  group drv/Reset
    drv/Portable/Reset/: Reset.c
  group drv/SPI_Adapter
    drv/Portable/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group drv/TMR_Adapter
    drv/Portable/TMR_Adapter/: TMR_Adapter.c TMR_Adapter.h
  group drv/USB_VirtualCom
    drv/Portable/USB_VirtualCom/: usb_descriptor.c usb_descriptor.h virtual_com.c virtual_com.h VirtualComInterface.h
  group framework/Common
    framework/Common/: EmbeddedTypes.h FwkInit.c
  group framework/FSCI/Interface
    framework/FSCI/Interface/: FSCIConfig.h FsciInterface.h
  group framework/FSCI/Source
    framework/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/LPM/Interface/KW2xD
    framework/LPM/Interface/KW2xD/: LPMConfig.h PWR_Configuration.h PWR_Interface.h
  group framework/LPM/Source/KW2xD
    framework/LPM/Source/KW2xD/: PWR.c PWRLib.c PWRLib.h
  group framework/MemManager/Interface
    framework/MemManager/Interface/: MemManager.h MemManagerConfig.h
  group framework/MemManager/Source
    framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    framework/Messaging/Source/: Messaging.c
  group framework/NVM/Interface
    framework/NVM/Interface/: NVM_Interface.h NVMConfig.h
  group framework/NVM/Source
    framework/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/OSAbstraction/Interface
    framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/OSAbstraction/Source
    framework/OSAbstraction/Source/: fsl_osa_ext_freertos.c
  group framework/OtaSupport/Interface
    framework/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    framework/OtaSupport/Source/: OtaSupport.c
  group framework/Panic/Interface
    framework/Panic/Interface/: Panic.h PanicConfig.h
  group framework/Panic/Source
    framework/Panic/Source/: Panic.c
  group framework/RNG/Interface
    framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    framework/RNG/Source/: RNG.c
  group framework/SerialManager/Interface
    framework/SerialManager/Interface/: SerialManager.h SerialManagerConfig.h
  group framework/SerialManager/Source
    framework/SerialManager/Source/: SerialManager.c
  group framework/Shell/Interface
    framework/Shell/Interface/: shell.h shell_config.h
  group framework/Shell/Source
    framework/Shell/Source/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group framework/TimersManager/Interface
    framework/TimersManager/Interface/: TimersManager.h TimersManagerConfig.h
  group framework/TimersManager/Source
    framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h
  group framework/Utils/FunctionLib
    framework/Utils/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Utils/Lists
    framework/Utils/Lists/: GenericList.c GenericList.h
  group framework/Utils/ModuleInfo
    framework/Utils/ModuleInfo/: ModuleInfo.h
  group framework/Utils/SecLib
    framework/Utils/SecLib/: lib_crypto_IAR_M4.a lib_mmcau.a mmcau_interface.h SecLib.c SecLib.h SecLibConfig.h
  group free-rtos
    $_KSDK_PATH_KINETIS_BEESTACK_500_$/rtos/FreeRTOS/src/: croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c
    $_KSDK_PATH_KINETIS_BEESTACK_500_$/rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    $_KSDK_PATH_KINETIS_BEESTACK_500_$/rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
  group ieee_802_15_4
    ieee_802_15_4/Lib/: Freescale_802.15.4_MAC_ZP_M4_IAR.a
  group ieee_802_15_4/App
    ieee_802_15_4/Source/App/: FsciMacCommands.c FsciMacCommands.h MacGlobals.c MacGlobals.h
  group ieee_802_15_4/MAC/Interface
    ieee_802_15_4/Source/Mac/Interface/: MacConfig.h MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802_15_4/PHY/Interface
    ieee_802_15_4/Source/Phy/Interface/: AspInterface.h MpmInterface.h Phy.h PhyConfig.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802_15_4/PHY/Source/MCR20A
    ieee_802_15_4/Source/Phy/Source/MCR20A/: ASP.c MPM.c PhyDebug.c PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group ieee_802_15_4/PHY/Source/MCR20A/MCR20
    ieee_802_15_4/Source/Phy/Source/MCR20A/MCR20Drv/: MCR20Drv.c MCR20Drv.h MCR20Overwrites.h MCR20Reg.h
  group ieee_802_15_4/PHY/Source/XcvrSPI
    ieee_802_15_4/Source/Phy/Source/XcvrSpi/: SPI.c SPI.h
  group startup
    $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/devices/: startup.c startup.h
    $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/devices/MKW24D5/startup/iar/: startup_MKW24D5.s
    $_KSDK_PATH_KINETIS_BEESTACK_500_$/platform/devices/MKW24D5/startup/: system_MKW24D5.c
  group zbpro/base/interface
    zbpro/base/interface/: BeeCommon.h BeeStack_Globals.h BeeStackCalculations.h BeeStackConfiguration.h BeeStackFunctionality.h BeeStackIBManagement.h BeeStackInit.h BeeStackInterface.h BeeStackNvmDataSets.h BeeStackNVMManagement.h BeeStackRamAlloc.h BeeStackTasksTbl.h BeeStackUtil.h CSkipCalc.h MsgSystem.h NV_Data.h NwkMacInterface.h TMR_Interface.h TS_Interface.h ZbAppInterface.h zigbee.h ZigbeeTask.h
  group zbpro/base/stackglobals
    zbpro/base/stackglobals/: AppStackImpl.c BeeStack_Globals.c BeeStackIBManagement.c BeeStackInit.c BeeStackNVMManagement.c BeeStackRamAlloc.c BeeStackUtil.c ZbAppInterface.c
  group zbpro/base/util
    zbpro/base/util/: BeeCommon.c InternalTimers.c NV_Data.c SystemTimer.c TS.c ZigbeeTask.c
  group zbpro/base/ztc/Interface
    zbpro/base/ztc/Interface/: AspZtc.h ZtcInterface.h
  group zbpro/base/ztc/Source
    zbpro/base/ztc/Source/: ZtcClientCommunication.h ZtcCopyData.c ZtcCopyData.h ZtcCopyDataTbl.h ZtcIBManagement.c ZtcIBManagement.h ZtcMacPIB.h ZtcMain.c ZtcMsgTypeInfo.c ZtcMsgTypeInfo.h ZtcMsgTypeInfoTbl.h ZtcPrivate.h ZtcSAPHandlerInfo.c ZtcSAPHandlerInfo.h ZtcSAPHandlerInfoTbl.h
  group zbpro/core/interface
    zbpro/core/interface/: AfApsInterface.h AfVariables.h AfZdoInterface.h AppAfInterface.h AppZdoInterface.h ApsDataInterface.h ApsMgmtInterface.h ApsVariables.h NwkCommon.h NwkVariables.h ZdoApsInterface.h ZdoNwkInterface.h
  group zbpro/core/lib
    zbpro/core/lib/: BeeStackZcRsRNPSp2_M4.a
  group zbpro/core/zdo
    zbpro/core/zdo/: ZdoBindManager.c ZdoMain.c ZdoNwkManager.c ZdoSecurityManager.c ZDOStateMachineHandler.c ZdoVariables.c ZdpFrequencyAgility.c ZdpManager.c ZdpRequests.c ZdpResponses.c ZdpUtils.c
  group zbpro/core/zdo/interface
    zbpro/core/zdo/interface/: ZdoBindManager.h ZdoMain.h ZdoNwkManager.h ZdoSecurityManager.h ZDOStateMachineHandler.h ZdoVariables.h ZdpFrequencyAgility.h ZdpManager.h ZdpRequests.h ZdpResponses.h ZdpUtils.h
  group zbpro/zcl
    zbpro/zcl/: EzCommissioning.c EzCommissioning.h ZCL.h ZclClosures.c ZclClosures.h ZclEnergyHome.c ZclEnergyHome.h ZclFoundation.c ZclFoundation.h ZclGeneral.c ZclGeneral.h ZclGlobals.c ZclHc.c ZclHc.h ZclHomeAutomation.c ZclHomeAutomation.h ZclHVAC.c ZclHVAC.h ZclLighting.c ZclLighting.h ZclMain.c ZclOptions.h ZclOTA.c ZclOTA.h ZclPartition.c ZclPartition.h ZclProtocInterf.c ZclProtocInterf.h zclSE.c zclSE.h ZclSECalendar.c ZclSECalendar.h ZclSecAndSafe.c ZclSecAndSafe.h ZclSEDevMgmt.c ZclSEDevMgmt.h ZclSEDRLC.c ZclSEDRLC.h ZclSEKeyEstab.c ZclSEKeyEstab.h ZclSEMDUPairing.c zclSEMDUPairing.h ZclSEMessaging.c ZclSEMessaging.h ZclSEMetering.c ZclSEMetering.h ZclSensing.c ZclSensing.h ZclSEPrepayment.c ZclSEPrepayment.h ZclSEPrice.c zclSEPrice.h ZclSETunneling.c ZclSETunneling.h ZclTelecom.c ZclTelecom.h ZclZtc.c ZclZtc.h ZllCommissioning.c ZllCommissioning.h
  group zbpro/zcl/ha
    zbpro/zcl/ha/: HaProfile.c HaProfile.h
  group zbpro/zcl/hc
    zbpro/zcl/hc/: HcProfile.c HcProfile.h HcZtc.c HcZtc.h NomenclatureCodes.h Oep11073.c Oep11073.h OepAgent.c OepAgent.h OEPClassSupport.c OEPClassSupport.h OepManager.c OepManager.h OEPTypes.h
  group zbpro/zcl/se
    zbpro/zcl/se/: libecc.a SEProfile.c SEprofile.h
