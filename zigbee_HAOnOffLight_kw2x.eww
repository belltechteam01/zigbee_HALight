<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_freertos_lib</project><configuration>debug</configuration></member><member><project>usbd_sdk_frdmkw24_freertos</project><configuration>Debug</configuration></member><member><project>zigbee_HAOnOffLight_kw2x</project><configuration>Debug</configuration></member><member><project>ksdk_freertos_lib</project><configuration>release</configuration></member><member><project>usbd_sdk_frdmkw24_freertos</project><configuration>Release</configuration></member><member><project>zigbee_HAOnOffLight_kw2x</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_freertos_lib</project><configuration>debug</configuration></member><member><project>usbd_sdk_frdmkw24_freertos</project><configuration>Debug</configuration></member><member><project>zigbee_HAOnOffLight_kw2x</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_freertos_lib</project><configuration>release</configuration></member><member><project>usbd_sdk_frdmkw24_freertos</project><configuration>Release</configuration></member><member><project>zigbee_HAOnOffLight_kw2x</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/zigbee_HAOnOffLight_kw2x.ewp</path></project><project><path>$_KSDK_PATH_KINETIS_BEESTACK_500_$/lib/ksdk_freertos_lib/iar/KW24D5/ksdk_freertos_lib.ewp</path></project><project><path>$_KSDK_PATH_KINETIS_BEESTACK_500_$/usb/usb_core/device/build/iar/usbd_sdk_frdmkw24_freertos/usbd_sdk_frdmkw24_freertos.ewp</path></project></workspace>
